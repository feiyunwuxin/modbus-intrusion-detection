# Keil uVision project H743test_TFLM.uvprojx, settings and files
target H743test_TFLM (6240000::V6.24::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: H743test_TFLM +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=8 wLevel=2
  c define: USE_PWR_LDO_SUPPLY,USE_HAL_DRIVER,STM32H743xx,DEBUG_DUMP_FEATS=1,ARMCM7,CMSIS_DEVICE_ARM_CORTEX_M_XX_HEADER_FILE="stm32h743xx.h",CH32_BACKEND_TFLM=1
  c misc: --include ../Core/Inc/tflm_defs.h
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../thirdParty/tflite-micro;../thirdParty/flatbuffers/include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: H743_TFLM_arena.sct
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c modbus_ids.c sliding_window.c feature_extractor.c modbus_rtu.c ch32_inference_tflm.c model_tflm_fp32_s42_data.c
  group Application/User/TFLM
    ../Core/Src/: tflm_runtime.cpp
  group TFLite-Micro/Core
    ../thirdParty/tflite-micro/tensorflow/lite/micro/: micro_interpreter.cc micro_interpreter_graph.cc micro_interpreter_context.cc micro_allocator.cc micro_allocation_info.cc micro_common.cc micro_context.cc micro_log.cc micro_op_resolver.cc micro_profiler.cc micro_resource_variable.cc micro_time.cc micro_utils.cc debug_log.cc hexdump.cc flatbuffer_conversions.cc flatbuffer_utils.cc memory_helpers.cc
  group TFLite-Micro/Arena
    ../thirdParty/tflite-micro/tensorflow/lite/micro/arena_allocator/: single_arena_buffer_allocator.cc non_persistent_arena_buffer_allocator.cc persistent_arena_buffer_allocator.cc
  group TFLite-Micro/MemoryPlanner
    ../thirdParty/tflite-micro/tensorflow/lite/micro/memory_planner/: greedy_memory_planner.cc linear_memory_planner.cc non_persistent_buffer_planner_shim.cc
  group TFLite-Micro/Kernels
    ../thirdParty/tflite-micro/tensorflow/lite/micro/kernels/: kernel_util.cc conv.cc conv_common.cc fully_connected.cc fully_connected_common.cc reduce.cc reduce_common.cc mul.cc mul_common.cc add.cc add_common.cc logistic.cc logistic_common.cc reshape.cc reshape_common.cc transpose.cc transpose_common.cc expand_dims.cc activations.cc activations_common.cc
  group TFLite-Micro/KernelsInternal
    ../thirdParty/tflite-micro/tensorflow/lite/micro/kernels/internal/: common.cc portable_tensor_utils.cc quantization_util.cc runtime_shape.cc tensor_ctypes.cc
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
software components: CMSIS:CORE 4.3.0
